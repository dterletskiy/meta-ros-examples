IMAGE_INSTALL:append = " \
   frame-msgs \
   frame-publisher \
   frame-subscriber \
"
